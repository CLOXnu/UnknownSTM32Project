# Keil uVision project 1.uvproj, settings and files
target 1 (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: 1
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group boot
    ./boot/: cortexm3_macro.s stm32f10x_vector.s
  group library
    ./library/src/: stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_rcc.c
  group interrupt
    ./interrupt/: stm32f10x_it.c
  group src
    ./src/: main.c
